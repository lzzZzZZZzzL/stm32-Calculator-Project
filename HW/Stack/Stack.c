/*********************************************************************************************************
* 模块名称：Stack.h
* 摘    要：栈模块
* 当前版本：1.0.0
* 作    者：Lzy
* 完成日期：
* 内    容：
* 注    意：                                                                  
**********************************************************************************************************
* 取代版本：
* 作    者：
* 完成日期：
* 修改内容：
* 修改文件：
*********************************************************************************************************/

/*********************************************************************************************************
*                                              包含头文件
*********************************************************************************************************/
#include "Stack.h"
/*********************************************************************************************************
*                                              宏定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              枚举结构体定义
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部变量
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部函数声明
*********************************************************************************************************/

/*********************************************************************************************************
*                                              内部函数实现
*********************************************************************************************************/

/*********************************************************************************************************
*                                              API函数实现
*********************************************************************************************************/
/*********************************************************************************************************
* 函数名称：InitStack
* 函数功能：初始化栈
* 输入参数：
*   pStack - 指向栈结构体的指针
*   pBuf - 指向存储栈数据的缓冲区
*   len - 栈的最大容量
* 输出参数：无
* 返 回 值：无
* 创建日期：
* 注    意：
*********************************************************************************************************/
void InitStack(StructStack* pStack, STACK_TYPE* pBuf, i16 len)
{
  pStack->top = -1;
  pStack->maxSize = len;// 设置栈的最大容量
  pStack->pBuffer = pBuf;// 将缓冲区指针赋给栈
}

/*********************************************************************************************************
* 函数名称：ClearStack
* 函数功能：清空栈
* 输入参数：pStack - 指向栈结构体的指针
* 输出参数：无
* 返 回 值：无
* 创建日期：
* 注    意：
*********************************************************************************************************/
void ClearStack(StructStack* pStack)
{
  pStack->top = -1;
}

/*********************************************************************************************************
* 函数名称：StackEmpty
* 函数功能：判断栈是否为空
* 输入参数：pStack - 指向栈结构体的指针
* 输出参数：无
* 返 回 值：
*   1 - 栈为空
*   0 - 栈不为空
* 创建日期：
* 注    意：
*********************************************************************************************************/
u8 StackEmpty(StructStack* pStack)
{
  return (pStack->top == -1);
}

/*********************************************************************************************************
* 函数名称：StackFull
* 函数功能：判断栈是否已满
* 输入参数：pStack - 指向栈结构体的指针
* 输出参数：无
* 返 回 值：
*   1 - 栈已满
*   0 - 栈未满
* 创建日期：
* 注    意：
*********************************************************************************************************/
u8 StackFull(StructStack* pStack)
{
  return (pStack->top == pStack->maxSize - 1);
}

/*********************************************************************************************************
* 函数名称：PushStack
* 函数功能：入栈
* 输入参数：
*   pStack - 指向栈结构体的指针
*   data - 要入栈的数据
* 输出参数：无
* 返 回 值：
*   1 - 入栈成功
*   0 - 入栈失败（栈已满）
* 创建日期：
* 注    意：
*********************************************************************************************************/
u8 PushStack(StructStack* pStack, STACK_TYPE data)
{
  if (StackFull(pStack))
  {
    return 0;
  }
  pStack->pBuffer[++pStack->top] = data;
  return 1;
}

/*********************************************************************************************************
* 函数名称：PopStack
* 函数功能：出栈
* 输入参数：
*   pStack - 指向栈结构体的指针
*   pData - 指向存储出栈数据的变量指针
* 输出参数：pData - 出栈的数据
* 返 回 值：
*   1 - 出栈成功
*   0 - 出栈失败（栈为空）
* 创建日期：
* 注    意：
*********************************************************************************************************/
u8 PopStack(StructStack* pStack, STACK_TYPE* pData)
{
  if (StackEmpty(pStack))
  {
    return 0;
  }
  *pData = pStack->pBuffer[pStack->top--];
  return 1;
}

/*********************************************************************************************************
* 函数名称：PeekStack
* 函数功能：查看栈顶元素
* 输入参数：
*   pStack - 指向栈结构体的指针
*   pData - 指向存储栈顶数据的变量指针
* 输出参数：pData - 栈顶的数据
* 返 回 值：
*   1 - 查看成功
*   0 - 查看失败（栈为空）
* 创建日期：
* 注    意：
*********************************************************************************************************/
u8 PeekStack(StructStack* pStack, STACK_TYPE* pData)
{
  if (StackEmpty(pStack))
  {
    return 0;
  }
  *pData = pStack->pBuffer[pStack->top];
  return 1;
}
